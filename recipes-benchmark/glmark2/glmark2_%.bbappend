# Some opengl[es] libraries are multithreaded.
LDFLAGS += "-pthread"
