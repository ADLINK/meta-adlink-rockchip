
DEPENDS += "rockchip-librga"
