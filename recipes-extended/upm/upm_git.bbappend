

SRC_URI += "file://0001-Added-a-flag-to-build-upm-examples.patch \
	    file://0002-Changed-I2C-bus-number-from-0-to-1.patch" 

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
