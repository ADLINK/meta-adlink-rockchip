LDFLAGS_append = " -lmali"
